SRC_URI:buv-runbmc := "git://github.com/Nuvoton-Israel/pmci.git;branch=master;protocol=https"
SRCREV:buv-runbmc := "bbbe833676c74b61fdc7bcc67d756eb8f557641a"
