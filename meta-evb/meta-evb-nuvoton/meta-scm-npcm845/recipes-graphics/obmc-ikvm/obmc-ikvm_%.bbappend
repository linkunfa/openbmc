LIC_FILES_CHKSUM = "file://LICENSE;md5=d32239bcb673463ab874e80d47fae504"
SRC_URI:nuvoton := "git://github.com/Nuvoton-Israel/obmc-ikvm.git;branch=master;protocol=https"
SRCREV:nuvoton := "40f879557d7fe612a6dac6dbc0d1dbdca1eacfc5"
