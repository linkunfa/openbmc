EXTRA_OECONF_append_evb-npcm845 = " --disable-link-local-autoconfiguration --with-uboot-env"
