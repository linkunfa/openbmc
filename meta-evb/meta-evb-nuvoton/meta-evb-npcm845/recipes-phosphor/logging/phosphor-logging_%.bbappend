FILESEXTRAPATHS_append_evb-npcm845 := "${THISDIR}/${PN}:"

SRC_URI_append_evb-npcm845 = " file://0001-Fix-wrong-type-of-TRANSACTION_ID-metadata.patch"

