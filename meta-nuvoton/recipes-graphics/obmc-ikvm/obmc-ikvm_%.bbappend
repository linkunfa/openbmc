LIC_FILES_CHKSUM = "file://LICENSE;md5=d32239bcb673463ab874e80d47fae504"
SRC_URI_nuvoton := "git://github.com/Nuvoton-Israel/obmc-ikvm"
SRCREV_nuvoton := "931e11f4cef523757a45b9d12e8689dc5241bc22"

#LIC_FILES_CHKSUM = "file://LICENSE;md5=75859989545e37968a99b631ef42722e"
#SRC_URI:nuvoton := "git://github.com/Nuvoton-Israel/obmc-ikvm;branch=upstream-v4l2"
#SRCREV:nuvoton := "e7ae01193609dd86ef982a4641fefa2cc8af8f12"
