SRC_URI:olympus-nuvoton := "git://github.com/Nuvoton-Israel/pmci.git;protocol=https;branch=master"
SRCREV:olympus-nuvoton := "757e8129230516d61262603c6cd93248064ee030"
